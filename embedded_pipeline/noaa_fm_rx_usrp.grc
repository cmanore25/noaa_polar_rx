options:
  parameters:
    author: Curtis Manore
    description: FM receive pipeline for NOAA APT transmission
    generate_options: qt_gui
    id: noaa_fm_rx_usrp
    output_language: python
    title: noaa_fm_rx_usrp
  states: {}

blocks:
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '38000'
  states: {}
- name: filter_decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 137.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: transition_bw
  id: variable_qtgui_range
  parameters:
    label: Transition BW (kHz)
    start: '10000'
    step: '1000'
    stop: '40000'
    value: '20000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: volume
    min_len: '10'
    start: '0'
    step: '0.5'
    stop: '5'
    value: '1.5'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: '250000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: Computer Audio
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: filter_decimation
    samp_rate: samp_rate
    taps: ' firdes.low_pass(1,samp_rate,samp_rate/(2*filter_decimation), transition_bw)'
    type: ccf
  states: {}
- name: note_0
  id: note
  parameters:
    note: Could increase to 500k and decimation of 10
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Lower trans_bw = more computation
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Center freq = freq shift
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '250000'
    fc: frequency
    fftsize: '512'
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    fbw: '0.0'
    interp: '441'
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bandwidth
    center_freq0: frequency
    dev_args: '""'
    gain0: RF_Gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
